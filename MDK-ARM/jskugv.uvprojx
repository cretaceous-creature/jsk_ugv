# Keil uVision project jskugv.uvprojx, settings and files
target jskugv (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F746VGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.5.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: jskugv +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,__cplusplus,__USE_C99_MATH
  c misc: --CPP
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;..\Jsk_Lib\include;..\ros_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_spi.c stm32f7xx_hal_i2c.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma.c stm32f7xx_hal.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: usart.c i2c.c dma.c stm32f7xx_hal_msp.c gpio.c adc.c spi.c stm32f7xx_it.c tim.c main.cpp
  group ros
    ../ros_lib/: duration.cpp time.cpp
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
